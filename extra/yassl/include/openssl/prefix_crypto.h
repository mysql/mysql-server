#define SSLeay_version yaSSLeay_version
