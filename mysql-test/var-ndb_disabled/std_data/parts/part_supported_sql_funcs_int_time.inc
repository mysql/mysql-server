1	09:09:15.000002	
2	04:30:01.000018	
3	00:59:22.000024	
4	05:30:34.000037	
