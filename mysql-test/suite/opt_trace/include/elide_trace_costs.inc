let $elide_trace_costs = /"(cost)": [0-9.]+/"\1": NN/ /"(cost_for_plan)": [0-9.]+/"\1": NN/;
