let $num_stress_rows= 5000;
let $default_engine_type= myisam;
