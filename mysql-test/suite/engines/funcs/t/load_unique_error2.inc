1,abc
2,def
3,ghi
4,jkl
