1,'N,'N
2,'N,'N
3,'N,'N
