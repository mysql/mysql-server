--disable_query_log
echo Starting timer...;
set @start = now();
--enable_query_log
