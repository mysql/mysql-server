DROP SCHEMA OBJECTS_TEST;

