--source include/rpl/init_source_replica.inc
