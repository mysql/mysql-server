select @@local_infile;
