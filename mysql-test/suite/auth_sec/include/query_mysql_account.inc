SELECT CURRENT_USER();
