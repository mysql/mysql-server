--let $show_binlog_events_mask_columns= 1, 2, 4, 5
--source include/rpl/deprecated/show_binlog_events.inc
