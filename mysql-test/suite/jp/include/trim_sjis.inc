#
# Test TRIM() function with Japanese characters sjis encoding
#

--source include/have_sjis.inc
--character_set sjis
SET NAMES sjis;
SET character_set_database = sjis;

--disable_warnings
DROP TABLE IF EXISTS `ВsВP`;
DROP TABLE IF EXISTS `ВsВQ`;
DROP TABLE IF EXISTS `ВsВR`;
--enable_warnings
--replace_result $engine <engine_to_be_tested>
eval CREATE TABLE `ВsВP` (`ВbВP` CHAR(12), INDEX(`ВbВP`)) DEFAULT CHARSET = sjis ENGINE = $engine;
--replace_result $engine <engine_to_be_tested>
eval CREATE TABLE `ВsВQ` (`ВbВP` CHAR(12), INDEX(`ВbВP`)) DEFAULT CHARSET = sjis ENGINE = $engine;
--replace_result $engine <engine_to_be_tested>
eval CREATE TABLE `ВsВR` (`ВbВP` CHAR(12), INDEX(`ВbВP`)) DEFAULT CHARSET = sjis ENGINE = $engine;

# Nothing to trim
INSERT INTO `ВsВP` VALUES ('▒▓│┤╡');
# Test data for TRIM(TRAILING [remstr] FROM str)
INSERT INTO `ВsВP` VALUES ('▒▓│┤╡╢');
INSERT INTO `ВsВP` VALUES ('▒▓│┤╡╢╢');
INSERT INTO `ВsВP` VALUES ('▒▓│┤╡╢╢╢');
# Test data for TRIM(LEADING [remstr] FROM str)
INSERT INTO `ВsВP` VALUES ('╢▒▓│┤╡');
INSERT INTO `ВsВP` VALUES ('╢╢▒▓│┤╡');
INSERT INTO `ВsВP` VALUES ('╢╢╢▒▓│┤╡');
# Test data for TRIM(BOTH [remstr] FROM str)
INSERT INTO `ВsВP` VALUES ('╢╢╢▒▓│┤╡╢╢╢');
# Test data for TRIM without [remstr] (remove spaces) 
INSERT INTO `ВsВP` VALUES ('   ▒▓│┤╡   ');
INSERT INTO `ВsВQ` VALUES ('ВаВвВдВжВи');
INSERT INTO `ВsВQ` VALUES ('ВаВвВдВжВиВй');
INSERT INTO `ВsВQ` VALUES ('ВаВвВдВжВиВйВй');
INSERT INTO `ВsВQ` VALUES ('ВаВвВдВжВиВйВйВй');
INSERT INTO `ВsВQ` VALUES ('ВйВаВвВдВжВи');
INSERT INTO `ВsВQ` VALUES ('ВйВйВаВвВдВжВи');
INSERT INTO `ВsВQ` VALUES ('ВйВйВйВаВвВдВжВи');
INSERT INTO `ВsВQ` VALUES ('ВйВйВйВаВвВдВжВиВйВйВй');
INSERT INTO `ВsВQ` VALUES ('   ВаВвВдВжВи   ');
INSERT INTO `ВsВR` VALUES ('Г\П\Х\Ч\Н\');
INSERT INTO `ВsВR` VALUES ('Г\П\Х\Ч\Н\Ц\');
INSERT INTO `ВsВR` VALUES ('Г\П\Х\Ч\Н\Ц\Ц\');
INSERT INTO `ВsВR` VALUES ('Г\П\Х\Ч\Н\Ц\Ц\Ц\');
INSERT INTO `ВsВR` VALUES ('Ц\Г\П\Х\Ч\Н\');
INSERT INTO `ВsВR` VALUES ('Ц\Ц\Г\П\Х\Ч\Н\');
INSERT INTO `ВsВR` VALUES ('Ц\Ц\Ц\Г\П\Х\Ч\Н\');
INSERT INTO `ВsВR` VALUES ('Ц\Ц\Ц\Г\П\Х\Ч\Н\Ц\Ц\Ц\');
INSERT INTO `ВsВR` VALUES ('   Г\П\Х\Ч\Н\   ');

SELECT `ВbВP`,TRIM(TRAILING '╢' FROM `ВbВP`) FROM `ВsВP`;
SELECT `ВbВP`,TRIM(LEADING '╢' FROM `ВbВP`) FROM `ВsВP`;
SELECT `ВbВP`,TRIM(BOTH '╢' FROM `ВbВP`) FROM `ВsВP`;
SELECT `ВbВP`,TRIM(`ВbВP`) FROM `ВsВP`;
SELECT `ВbВP`,TRIM(TRAILING 'Вй' FROM `ВbВP`) FROM `ВsВQ`;
SELECT `ВbВP`,TRIM(LEADING 'Вй' FROM `ВbВP`) FROM `ВsВQ`;
SELECT `ВbВP`,TRIM(BOTH 'Вй' FROM `ВbВP`) FROM `ВsВQ`;
SELECT `ВbВP`,TRIM(`ВbВP`) FROM `ВsВQ`;
SELECT `ВbВP`,TRIM(TRAILING 'Ц\' FROM `ВbВP`) FROM `ВsВR`;
SELECT `ВbВP`,TRIM(LEADING 'Ц\' FROM `ВbВP`) FROM `ВsВR`;
SELECT `ВbВP`,TRIM(BOTH 'Ц\' FROM `ВbВP`) FROM `ВsВR`;
SELECT `ВbВP`,TRIM(`ВbВP`) FROM `ВsВR`;

DROP TABLE `ВsВP`;
DROP TABLE `ВsВQ`;
DROP TABLE `ВsВR`;
