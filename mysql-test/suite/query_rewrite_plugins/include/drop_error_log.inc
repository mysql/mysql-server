eval DROP TABLE $error_log_table_name;
DROP FUNCTION search_error_log;
