let TESTED_DATADIR_VERSION = 5.7.9;
let ZIP_FILE = 5_7_9_clean.zip;
let LOG_ALLOW_UPGRADE = 1;
let LOG_FORMAT_MESSAGE = Redo log format is v1\. The redo log was created before MySQL 8\.0\.;
