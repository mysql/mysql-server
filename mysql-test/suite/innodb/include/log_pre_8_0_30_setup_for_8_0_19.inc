let TESTED_DATADIR_VERSION = 8.0.19;
let ZIP_FILE = 8_0_19_clean.zip;
let LOG_ALLOW_UPGRADE = 1;
let LOG_FORMAT_MESSAGE = Redo log format is v4\. The redo log was created before MySQL 8\.0\.;
