let $PATTERN_APPLY_BATCH_COMPLETED=Apply batch completed;
let $UNKNOWN_PARAM=innodb-unknown-compound-v;
let $PATTERN_UNKNOWN_PARAM=$UNKNOWN_PARAM;
let $PATTERN_APPLYING_BATCH=Applying a batch of.*redo log records;
let $PATTERN_STARTING_CRASH_RECOVERY=Starting crash recovery;
let $PATTERN_DATABASE_NOT_CLEAN=Database was not shutdown normally;
let $PATTERN_RECOVERY_UP_TO=Doing recovery: scanned up to log sequence number;
let $PATTERN_CORRUPT_LOG_RECORD=CORRUPT LOG RECORD FOUND;