#
# Keep in sync with lock0lock.cc LOCK_CATS_THRESHOLD
#

--let LOCK_CATS_THRESHOLD = 32