--force-rmdir $bugdir/data
--force-cpdir $bugdir/data_backup $bugdir/data
