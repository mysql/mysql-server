let TESTED_DATADIR_VERSION = 5.7.8;
let ZIP_FILE = 5_7_8_clean.zip;
let LOG_ALLOW_UPGRADE = 0;
let LOG_FORMAT_MESSAGE = Unsupported redo log format \(v0\)\. The redo log was created before MySQL 5\.7\.9;
