let TESTED_DATADIR_VERSION=;
let ZIP_FILE=;
let LOG_ALLOW_UPGRADE=;
let LOG_FORMAT_MESSAGE=;
