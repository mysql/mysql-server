# This script reverts what has been modified by
# flush_dirty_pages_and_stop_flushing.inc

SET GLOBAL innodb_page_cleaner_disabled_debug = OFF;
