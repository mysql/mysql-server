DROP PROCEDURE show_locks;
DROP PROCEDURE register_connection;
DROP TABLE connections;