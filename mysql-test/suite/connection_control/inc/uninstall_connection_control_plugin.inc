# Uninstall connection_control plugin
--disable_warnings
UNINSTALL PLUGIN connection_control;
--enable_warnings
UNINSTALL PLUGIN connection_control_failed_login_attempts;
