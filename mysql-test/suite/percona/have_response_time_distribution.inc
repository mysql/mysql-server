if (`SELECT @@have_response_time_distribution != 'YES'`)
{
  --skip No response time distribution
}
