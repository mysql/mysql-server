FLUSH QUERY_RESPONSE_TIME;
