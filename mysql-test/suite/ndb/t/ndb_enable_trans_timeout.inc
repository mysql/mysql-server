# Reset to default
--exec $NDB_MGM --no-defaults --verbose=0 -e "ALL DUMP 2507" >> $NDB_TOOLS_OUTPUT

