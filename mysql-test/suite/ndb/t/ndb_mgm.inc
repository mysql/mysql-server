let $_mgm_cmd=$NDB_MGM;
let $_mgm_cmd=$_mgm_cmd;
#echo mgm_cmd: $_mgm_cmd;
