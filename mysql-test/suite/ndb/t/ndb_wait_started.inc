--source ndb_waiter.inc

--echo Waiting for started
--exec $_waiter_cmd > /dev/null
