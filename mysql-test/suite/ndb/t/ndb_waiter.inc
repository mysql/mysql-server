let $_waiter_cmd=$NDB_WAITER;
let $_waiter_cmd=$_waiter_cmd;
#echo waiter_cmd: $_waiter_cmd;
