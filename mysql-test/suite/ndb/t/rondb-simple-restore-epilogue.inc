
# Cleanup

--remove_file $t1m
--remove_file $t1d
--remove_file $t2m
--remove_file $t2d
--remove_file $t1m_compare
--remove_file $t1d_compare
--remove_file $t2m_compare
--remove_file $t2d_compare
--remove_file $trash
--source suite/ndb/include/backup_restore_cleanup.inc
