#   Set mtr variables

let $testing_ndb = 1;
let $skip_full_text_check = 1;
let $skip_spatial_index_check = 1;
let $support_virtual_index = 0;
