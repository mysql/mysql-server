1	1	
2	9	
3	3	
4	8	
