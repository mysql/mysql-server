1	5	
2	13	
3	15	
4	17	
5	23	
6	34	
7	56	
8	56	
9	45	
10	34	
11	78	
12	89	
13	67	
14	46	
15	34	
16	324	
17	345	
18	34	
19	78	
20	567	
21	4	
22	435	
23	34	
24	45	
25	4565	
26	4	
27	3	
28	2	
29	3	
30	5	
31	6	
32	8	
33	9	
34	745	
35	34	
36	34	
37	324	
38	67	
39	78	
40	89	
41	90	
42	78967	
50	56	
51	34	
55	123	