1	5.1230	
2	13.345	
3	17.987	
4	15.654	
