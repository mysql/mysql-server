if (!$GROUP_REPLICATION_RESOURCE_MANAGER) {
   --skip Requires the environment variable \$GROUP_REPLICATION_RESOURCE_MANAGER to be set (normally done by mtr). See the file plugin.defs.
}
