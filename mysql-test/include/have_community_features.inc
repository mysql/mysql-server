--require r/have_community_features.require
--disable_query_log
show variables like 'have_community_features';
--enable_query_log
