if (`SELECT $OPT_TRACE_PROTOCOL = 1`)
{
  --skip Test do not require opt-trace-protocol
}
