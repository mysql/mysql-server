--disable_query_log
SET @@GLOBAL.binlog_format=@previous_binlog_format__htnt542nh;
--enable_query_log
