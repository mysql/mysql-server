# Placeholder file for tests which use
# --loose-debug='+d,preserve_shared_objects_after_unload'
# which will be ignored in non-debug build.
