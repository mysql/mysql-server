-- require r/have_default_master.require
connection master;
show variables like "port";
