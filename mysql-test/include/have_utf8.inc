let collation=utf8_general_ci;
--source include/have_collation.inc
