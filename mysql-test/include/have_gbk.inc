let collation=gbk_chinese_ci;
--source include/have_collation.inc
