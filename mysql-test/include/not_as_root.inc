if ($MYSQL_TEST_ROOT){
  skip Not as root;
}
