if (!$GROUP_REPLICATION_FLOW_CONTROL_STATS) {
   --skip Requires the environment variable \$GROUP_REPLICATION_FLOW_CONTROL_STATS to be set (normally done by mtr). See the file plugin.defs.
}
