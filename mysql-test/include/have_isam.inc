-- require r/have_isam.require
disable_query_log;
show variables like "have_isam";
enable_query_log;
