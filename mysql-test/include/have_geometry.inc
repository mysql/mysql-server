--require r/have_geometry.require
--disable_query_log
show variables like 'have_geometry';
--enable_query_log
