let $rpl_connection_name= slave;
source include/rpl_connection.inc;
