-- require r/have_gemini.require
disable_query_log;
show variables like "have_gemini";
enable_query_log;
