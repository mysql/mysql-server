if ($VALGRIND_TEST)
{
  --skip Test requires 'not_valgrind'
}
