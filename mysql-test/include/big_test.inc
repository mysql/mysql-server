if (!$BIG_TEST)
{
  --skip Test needs 'big-test' option
}
