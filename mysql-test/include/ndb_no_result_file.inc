# Tests sourcing this include file shouldn't have its corresponding
# result file. This inc file is meant only for NDB tests and shouldn't
# be used in server tests.
