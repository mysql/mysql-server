--echo ===============
--echo create table & Index
--echo ===============

eval CREATE TABLE $table (col_1 text(10))
ENGINE=INNODB ;


