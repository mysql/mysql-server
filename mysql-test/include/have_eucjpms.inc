let collation=eucjpms_japanese_ci;
--source include/have_collation.inc
