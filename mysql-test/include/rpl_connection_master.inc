let $rpl_connection_name= master;
source include/rpl_connection.inc;