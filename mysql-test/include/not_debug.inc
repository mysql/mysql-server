if (`select version() like '%debug%'`)
{
  skip Does not run with debug binaries;
}

