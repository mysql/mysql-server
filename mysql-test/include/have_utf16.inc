-- require r/have_utf16.require
disable_query_log;
show collation like 'utf16_general_ci';
enable_query_log;
