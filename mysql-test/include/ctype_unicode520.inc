let $ucaver = 520;

--source include/ctype_uca_test.inc
