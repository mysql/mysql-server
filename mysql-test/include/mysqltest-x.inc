echo Output from mysqltest-x.inc;
exit;

