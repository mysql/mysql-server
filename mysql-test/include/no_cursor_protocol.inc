if (`SELECT $CURSOR_PROTOCOL = 1`)
{
  --skip Test requires: cursor-protocol disabled
}
