let collation=cp866_general_ci;
--source include/have_collation.inc
