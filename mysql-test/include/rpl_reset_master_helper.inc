# Auxiliary file used by rpl_reset.inc

RESET MASTER;
