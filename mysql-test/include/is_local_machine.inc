# Only run this test if its executed on local machine
if ($PB2WORKDIR != ''){
  skip Need local machine;
}
