let collation=tis620_thai_ci;
--source include/have_collation.inc
