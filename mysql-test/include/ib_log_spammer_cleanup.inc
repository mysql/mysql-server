--disable_query_log
DROP PROCEDURE log_spammer;
DROP PROCEDURE log_spam;
DROP TABLE log_spam_controller;
DROP TABLE log_spam;
--enable_query_log
