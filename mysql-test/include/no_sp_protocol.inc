if (`SELECT $SP_PROTOCOL = 1`)
{
  --skip Test requires: sp-protocol disabled
}
