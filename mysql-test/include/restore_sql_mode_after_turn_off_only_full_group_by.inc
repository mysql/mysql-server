--disable_query_log
set @@sql_mode=@previous_sql_mode_htnt542nh;
--enable_query_log

