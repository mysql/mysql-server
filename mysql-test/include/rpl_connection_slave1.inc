let $rpl_connection_name= slave1;
source include/rpl_connection.inc;