if (`SELECT $VIEW_PROTOCOL = 1`)
{
  --skip Test requires: view-protocol disabled
}
