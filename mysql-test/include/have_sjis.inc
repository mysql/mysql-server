let collation=sjis_japanese_ci;
--source include/have_collation.inc
