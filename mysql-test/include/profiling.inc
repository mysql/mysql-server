-- require r/profiling.require
disable_query_log;
show variables like "profiling";
enable_query_log;
