# Warning: This is an auto-generated file. Please do not modify it.
--let $max_indexes = 64U
