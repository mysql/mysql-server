if ( $rpl_privilege_checks_user != '' )
{
  --skip Doesn't support privilege checks on replication applier
}
if ( $PRIVILEGE_CHECKS_USER != '' )
{
  --skip Doesn't support privilege checks on replication applier
}
