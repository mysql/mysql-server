FLUSH OPTIMIZER_COSTS;

--disconnect default
--source include/wait_until_disconnected.inc
--connect (default,localhost,root,,test)
