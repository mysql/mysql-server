let collation=euckr_korean_ci;
--source include/have_collation.inc
