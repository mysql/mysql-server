-- require r/have_utf32.require
disable_query_log;
show collation like 'utf32_general_ci';
enable_query_log;
