let collation=koi8r_general_ci;
--source include/have_collation.inc
