let collation=cp1250_czech_cs;
--source include/have_collation.inc
