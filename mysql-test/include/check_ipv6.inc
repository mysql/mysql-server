# Check if ipv6 is available.
#
# The real check is done in the suite.pm
# (it has to be done *before* mysqld is started)
#
