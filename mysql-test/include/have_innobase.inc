-- require r/have_innobase.require
show variables like "have_innobase";
