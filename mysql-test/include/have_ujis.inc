let collation=ujis_japanese_ci;
--source include/have_collation.inc
