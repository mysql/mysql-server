-- require r/have_gb18030.require
disable_query_log;
show collation like 'gb18030_chinese_ci';
enable_query_log;
