let $rpl_connection_name= master1;
source include/rpl_connection.inc;
