if (!$GROUP_REPLICATION_PRIMARY_ELECT_PREFER_MOST_UPDATED) {
   --skip Requires the environment variable \$GROUP_REPLICATION_PRIMARY_ELECT_PREFER_MOST_UPDATED to be set (normally done by mtr). See the file plugin.defs.
}

