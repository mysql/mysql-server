if (`SELECT $JSON_EXPLAIN_PROTOCOL = 1`)
{
  --skip Test do not require json-explain-protocol
}
