let collation=cp932_japanese_ci;
--source include/have_collation.inc
