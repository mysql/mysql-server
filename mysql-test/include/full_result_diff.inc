# Including this file will produce full result diff when test fails instead of
# the default of 20 lines diff.
