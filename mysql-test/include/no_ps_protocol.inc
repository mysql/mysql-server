if (`SELECT $PS_PROTOCOL = 1`)
{
  --skip Test requires: ps-protocol disabled
}
