--source include/check_windows.inc
if (!$have_windows)
{
  skip Need windows;
}

