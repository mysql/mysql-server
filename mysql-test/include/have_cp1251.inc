let collation=cp1251_general_ci;
--source include/have_collation.inc
