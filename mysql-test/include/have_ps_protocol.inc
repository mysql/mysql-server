if (`SELECT $PS_PROTOCOL = 0`)
{
   --skip Need ps-protocol
}
