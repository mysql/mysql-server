let collation=ucs2_general_ci;
--source include/have_collation.inc
