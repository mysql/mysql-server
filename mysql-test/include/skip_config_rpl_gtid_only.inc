--let $skip_configuration_rpl_gtid_only = 'skip'
