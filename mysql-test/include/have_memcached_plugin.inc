if ($DAEMON_MEMCACHED_DIR == '')
{
	skip Memcached not available.;
}
