--echo # Checking for vector support
