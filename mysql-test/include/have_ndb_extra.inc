-- require r/have_ndb_extra.require
eval select $NDB_EXTRA_TEST;
