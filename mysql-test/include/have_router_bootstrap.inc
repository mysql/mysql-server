# Should be used by the Router test when it does not expect the Router
# to be automatically launched. For example bootstrap tests are like
# that. We perform the bootstrap in the test, the Router process is
# not expected for that.
