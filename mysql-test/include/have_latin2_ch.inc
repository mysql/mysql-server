let collation=latin2_czech_cs;
--source include/have_collation.inc
