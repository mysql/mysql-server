let collation=big5_chinese_ci;
--source include/have_collation.inc
