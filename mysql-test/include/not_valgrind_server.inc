if ($VALGRIND_SERVER_TEST)
{
  --skip Test requires 'not_valgrind_server'
}
