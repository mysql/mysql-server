#
# Cleanup of utility functions for working with ICU.
#

--disable_query_log
DROP FUNCTION icu_major_version;
--enable_query_log
