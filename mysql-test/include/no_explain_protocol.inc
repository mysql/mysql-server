if (`SELECT $EXPLAIN_PROTOCOL = 1`)
{
  --skip Test do not require explain-protocol
}
