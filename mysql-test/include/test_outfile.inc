eval select "Outfile OK" into outfile "$MYSQLTEST_VARDIR/tmp/outfile.test";
