let collation=gb2312_chinese_ci;
--source include/have_collation.inc
