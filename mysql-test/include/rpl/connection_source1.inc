let $rpl_connection_name= master1;
source include/connection.inc;
