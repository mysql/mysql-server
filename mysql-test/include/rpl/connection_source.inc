let $rpl_connection_name= master;
source include/connection.inc;
