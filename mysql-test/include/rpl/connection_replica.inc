let $rpl_connection_name= slave;
source include/connection.inc;
