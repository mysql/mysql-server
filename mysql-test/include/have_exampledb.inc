-- require r/have_exampledb.require
disable_query_log;
show variables like "have_example_engine";
enable_query_log;
