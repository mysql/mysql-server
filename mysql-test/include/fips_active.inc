if (!$OPENSSL3_FIPS_ACTIVE) {
  --skip OpenSSL 3 FIPS is not active
}
