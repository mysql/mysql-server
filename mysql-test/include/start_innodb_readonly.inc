let $restart_parameters = restart: --innodb-read-only;
--source include/start_mysqld.inc
let $restart_parameters=;
