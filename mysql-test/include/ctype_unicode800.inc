let $ucaver = 800;

--source include/ctype_uca_test.inc
