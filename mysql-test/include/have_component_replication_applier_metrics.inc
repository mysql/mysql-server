
if (!$REPLICATION_APPLIER_METRICS) {
   --skip Requires the environment variable \$REPLICATION_APPLIER_METRICS to be set (normally done by mtr). See the file plugin.defs.
}
