--let $skip_defaults_privilege_checks_user = 'skip'
--let $skip_configuration_privilege_checks_user = 'skip'
