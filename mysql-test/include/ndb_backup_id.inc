let $the_backup_id = `SELECT id FROM ndbinfo.backup_id`;
