if ($RUNNING_SUNW_DISCOVER) {
  --skip "Skip when running with --discover"
}
