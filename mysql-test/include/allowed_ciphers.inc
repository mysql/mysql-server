#
# List of TLSv1.2 and TLSv1.3 ciphers which will be
# replaced with "SSL_CIPHER" in the result files.
# Usage: --replace_regex $ALLOWED_CIPHERS_REGEX
#

LET $ALLOWED_CIPHERS_REGEX = /ECDHE-RSA-AES128-GCM-SHA256|DHE-RSA-AES128-GCM-SHA256|DHE-RSA-AES256-SHA|ECDHE-RSA-AES128-SHA256|TLS_AES_128_GCM_SHA256|TLS_AES_256_GCM_SHA384|TLS_CHACHA20_POLY1305_SHA256|DHE-RSA-CHACHA20-POLY1305/SSL_CIPHER/;
