--source include/check_windows.inc
if ($have_windows)
{
  --skip Test requires 'not_windows'
}
