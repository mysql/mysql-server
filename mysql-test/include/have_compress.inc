-- require r/have_compress.require
disable_query_log;
show variables like 'have_compress';
enable_query_log;
