../../windows/tests/test-filesystem-sizes.c