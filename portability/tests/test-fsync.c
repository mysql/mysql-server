../../windows/tests/test-fsync.c