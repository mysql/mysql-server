../../windows/tests/test-pthread-rwlock-rdlock.c