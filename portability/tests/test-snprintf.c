../../windows/tests/test-snprintf.c