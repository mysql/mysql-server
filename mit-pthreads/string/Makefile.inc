#	from: @(#)Makefile.inc	5.21 (Berkeley) 5/24/91
#	$Id$

# string sources
.PATH: ${srcdir}/string

SRCS+= strtok.c

