#define HUGE_VAL    1.7976931348623157e+308


