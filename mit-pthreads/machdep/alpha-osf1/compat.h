#define omsghdr msghdr
