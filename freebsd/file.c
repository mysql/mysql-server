../portability/file.c