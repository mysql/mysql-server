../../portability/tests/test-pthread-rwlock-rdlock.c