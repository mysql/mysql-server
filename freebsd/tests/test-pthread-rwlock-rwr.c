../../linux/tests/test-pthread-rwlock-rwr.c