../portability/toku_assert.c