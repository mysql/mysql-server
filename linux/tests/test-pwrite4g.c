../../windows/tests/test-pwrite4g.c