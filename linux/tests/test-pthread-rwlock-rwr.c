../../windows/tests/test-pthread-rwlock-rwr.c