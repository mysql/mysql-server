let $datadir=`select @@datadir`;
