connect (slave,localhost,root,,test,0,/var/lib/mysql/mysql.sock);
connect (master,sarochka,admin,,test,0,0);
