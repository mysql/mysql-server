../../portability/tests/test-pthread-rwlock-rwr.c