../../portability/tests/test-max-data.c