../../portability/tests/test-flock.c