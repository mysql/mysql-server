../../portability/tests/test-pwrite4g.c