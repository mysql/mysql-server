../portability/memory.c