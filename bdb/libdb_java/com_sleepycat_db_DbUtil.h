/* DO NOT EDIT THIS FILE - it is machine generated */
#include <jni.h>
/* Header for class com_sleepycat_db_DbUtil */

#ifndef _Included_com_sleepycat_db_DbUtil
#define _Included_com_sleepycat_db_DbUtil
#ifdef __cplusplus
extern "C" {
#endif
/* Inaccessible static: big_endian */
/*
 * Class:     com_sleepycat_db_DbUtil
 * Method:    is_big_endian
 * Signature: ()Z
 */
JNIEXPORT jboolean JNICALL Java_com_sleepycat_db_DbUtil_is_1big_1endian
  (JNIEnv *, jclass);

#ifdef __cplusplus
}
#endif
#endif
