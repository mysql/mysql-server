/* DO NOT EDIT THIS FILE - it is machine generated */
#include <jni.h>
/* Header for class com_sleepycat_db_DbLock */

#ifndef _Included_com_sleepycat_db_DbLock
#define _Included_com_sleepycat_db_DbLock
#ifdef __cplusplus
extern "C" {
#endif
/*
 * Class:     com_sleepycat_db_DbLock
 * Method:    finalize
 * Signature: ()V
 */
JNIEXPORT void JNICALL Java_com_sleepycat_db_DbLock_finalize
  (JNIEnv *, jobject);

#ifdef __cplusplus
}
#endif
#endif
