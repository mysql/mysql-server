/* This file is autogenerated */
string mysql_system_data[]= {
"CREATE TEMPORARY TABLE tmp_proxies_priv LIKE proxies_priv;\n",
"INSERT INTO tmp_proxies_priv VALUES ('localhost', 'root', '', '', TRUE, '', now());\n",
"REPLACE INTO tmp_proxies_priv SELECT LOWER(@current_hostname), 'root', '', '', TRUE, '', now() FROM DUAL WHERE LOWER (@current_hostname) != 'localhost';\n",
"INSERT INTO  proxies_priv SELECT * FROM tmp_proxies_priv WHERE @had_proxies_priv_table=0;\n",
"DROP TABLE tmp_proxies_priv;\n",
""};
